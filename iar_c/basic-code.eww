<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\color_functions.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\string_functions.ewp</path>
  </project>
  <batchBuild/>
</workspace>


